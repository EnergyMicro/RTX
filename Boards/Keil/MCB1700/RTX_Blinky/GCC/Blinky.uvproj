# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-GNU)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  group StartUp
    ./: startup_ARMCM3.s
    ../: system_LPC17xx.c
  group RTX Configuration
    ../: RTX_Conf_CM.c
  group RTX Library
    ../../../../../LIB/GCC/: libRTX_CM3.a
  group Source Files
    ../: GLCD_SPI_LPC1700.c LED.c Blinky.c
  group Documentation
    ../: Abstract.txt
target LPC1768 Flash (ARM-GNU)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Blinky
