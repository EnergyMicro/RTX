# Keil uVision project Example1.uvproj, settings and files
target Simulator (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Example1
  c flags: Optim=1
  c misc: --exceptions
  c include: ..\..\..\..\INC
  memory RVCT1: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_ARMCM3.s
    ../: system_ARMCM3.c
  group RTX Configuration
    ../: RTX_Conf_CM.c
  group RTX Library
    ../../../../LIB/ARM/: RTX_CM3.lib
  group Source Files
    ./: Retarget.c
    ../: Serial.c main.cpp
  group Documentation
    ../: Abstract.txt
