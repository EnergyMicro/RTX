# Keil uVision project Template.uvproj, settings and files
target Simulator (ARM-GNU)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Template
  group Startup
    ./: startup_ARMCM4.s
    ../: system_ARMCM4.c
  group RTX Configuration
    ../../: RTX_Conf_CM.c
  group RTX Library
    ../../../LIB/GCC/: libRTX_CM4.a
  group Source Files
    ../../: main.c
